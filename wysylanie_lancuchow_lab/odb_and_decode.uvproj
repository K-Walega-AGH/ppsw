# Keil uVision project odb_and_decode.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: decode_lab +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s led.c keyboard.c timerinterrupts.c serwo.c uart.c strings.c decode.c wys_lan_zn_main.c
